SUMMARY = "P8-4S board wiring"
DESCRIPTION = "Board wiring information for the P8-4S system."
PR = "r1"

inherit config-in-skeleton
