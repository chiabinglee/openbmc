FILESEXTRAPATHS_prepend_p8-4s := "${THISDIR}/${PN}:"
