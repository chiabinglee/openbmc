RDEPENDS_${PN}-inventory += "openpower-occ-control"
RDEPENDS_${PN}-extras += "phosphor-webui"