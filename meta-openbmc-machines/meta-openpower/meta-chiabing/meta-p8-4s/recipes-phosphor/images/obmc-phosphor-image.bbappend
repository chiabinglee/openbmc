OBMC_IMAGE_EXTRA_INSTALL_append = " mboxd p8-4s-set-vid p8-4s-uart-redir"
